# Keil uVision project project.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F205RC GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.4.0
  cpu: IRAM(0x20000000,0x020000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf.exe   --bin -o  .\Objects\project.bin .\Objects\project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL
  c include: ..\USER;..\GD32F20x_Firmware_Library\CMSIS;..\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include;..\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../USER/: gd32f20x_it.c main.c systick.c
    ../Driver/Source/: led.c usart.c gpio.c interrupt.c btim.c
  group GD32F20x_Firmware_Library
    ../GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
    ../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Startup
    ../Startup/: startup_gd32f20x_cl.s
  group FreeRTOS_Core
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
